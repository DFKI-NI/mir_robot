Commit message: Update wing flap to match planner footprint

File: mir_description/urdf/mir.urdf (robot description, URDF)
Before this commit: robot mir, 2 links, 1 joints
Links:
- link imu_link: geometry collision box size=8.2 0.1 1.0; visual box size=8.0 0.1 1.0
